KERNEL_FEATURES:append:qemuall ="\
	features/media/media-all.scc \
"
