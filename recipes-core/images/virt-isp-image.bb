inherit core-image

IMAGE_FEATURE += " ssh-server-dropbear debug-tweaks tools-debug dbg-pkgs"

IMAGE_INSTALL += " v4l-utils yavta"

IMAGE_INSTALL += " virt-isp-driver" 

